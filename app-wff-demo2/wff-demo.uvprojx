# Keil uVision project wff-demo.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L431CCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: demo-wff
  AfterMake: C:\Keil_v5\MDK\ARM\ARMCC\bin\fromelf.exe  --strip=comment,debug  --elf --output=Bin\@L.wff Objects\@L.axf
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10800
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\Objects\app-evasion.sct
  link misc: --entry=my_main   --first=my_main  --no_startup
  group Source Group 1
    ./: main.c api_table.s watchface_api.c
